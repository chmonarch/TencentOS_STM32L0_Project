# Keil uVision project STM32L051C8T6.uvprojx, settings and files
target STM32L051C8T6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L051C8T6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;..\..\..\arch\arm\arm-v7m\common\include;..\..\..\arch\arm\arm-v7m\cortex-m0+\armcc;..\..\..\kernel\core\include;..\..\..\kernel\pm\include;..\..\..\osal\cmsis_os;..\..\..\tickless;..\..\..\TOS_CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Application/User
    ../Src/: main.c gpio.c rtc.c tim.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group tos/arch
    ../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../arch/arm/arm-v7m/cortex-m0+/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
    ../../../kernel/pm/: tos_pm.c tos_tickless.c
  group tos/cmsis_os
    ../../../osal/cmsis_os/: cmsis_os.c
  group tos/tickless
    ../../../tickless/: bsp_pwr_mgr.c bsp_tickless_alarm.c bsp_pm_device.c
  group config
    ../../../TOS_CONFIG/: tos_config.h
software components: CMSIS:CORE 4.3.0
